# Keil uVision project project.uvproj, settings and files
target rtthread-stm32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: applications;.;drivers;Libraries\STM32F10x_StdPeriph_Driver\inc;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\rt-thread-2.0.2\components\CMSIS\Include;protocol;.;..\..\..\rt-thread-2.0.2\include;..\..\..\rt-thread-2.0.2\libcpu\arm\cortex-m3;..\..\..\rt-thread-2.0.2\libcpu\arm\common;..\..\..\rt-thread-2.0.2\components\drivers\include;..\..\..\rt-thread-2.0.2\components\drivers\include;..\..\..\rt-thread-2.0.2\components\drivers\spi;..\..\..\rt-thread-2.0.2\components\drivers\include;..\..\..\rt-thread-2.0.2\components\drivers\include;..\..\..\rt-thread-2.0.2\components\init
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep __rt_init*
  group Applications
    applications/: app_led.c app_machine.c app_manager.c app_nrf24l01.c app_test_mpu6050.c application.c startup.c
  group Drivers
    drivers/: board.c stm32f10x_it.c led.c usart.c nrf24l01.c platform.c machine.c drv_mpu6050.c stm32_i2c.c rt_stm32f10x_spi.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group protocol
    protocol/: CommunicationProtocol.c
  group Kernel
    ../../../rt-thread-2.0.2/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../../rt-thread-2.0.2/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../../rt-thread-2.0.2/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../rt-thread-2.0.2/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../rt-thread-2.0.2/components/drivers/serial/: serial.c
    ../../../rt-thread-2.0.2/components/drivers/spi/: spi_core.c spi_dev.c
    ../../../rt-thread-2.0.2/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group Components
    ../../../rt-thread-2.0.2/components/init/: components.c
